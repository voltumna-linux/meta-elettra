do_install_append() {
	rm ${D}${TI_CGT_PRU_INSTALL_DIR_RECIPE}/ti_cgt_pru_${PV}_uninstaller.run
}
